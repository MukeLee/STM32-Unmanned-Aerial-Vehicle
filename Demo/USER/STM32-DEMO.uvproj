# Keil uVision project STM32-DEMO.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-DEMO +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c misc: --c99
  c include: ..\Library\CMSIS;..\USER;..\Library\FWlib\inc;..\Library\FWlib\src;..\BSP\CONTROL;..\BSP\IIC;..\BSP\IMU;..\BSP\LED;..\BSP\MOTOR;..\BSP\MPU6050;..\BSP\PWM_IN;..\BSP\TIM;..\BSP\UART;..\BSP\Delay;..\BSP\HMC5883;..\BSP\ADC;..\BSP\KEY;..\BSP\OLED;..\BSP\APP;..\BSP\PARAM;..\BSP\NRF24L01;..\BSP\SPI;..\BSP\MS5611;..\BSP\EEPROM;..\Algorithm\Algorithm_filter;..\Algorithm\Algorithm_math
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUPCODE
    ../Library/CMSIS/: core_cm3.c system_stm32f10x.c
    ../Library/CMSIS/startup/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../Library/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Algorithm
    ../Algorithm/Algorithm_filter/: Algorithm_filter.c
    ../Algorithm/Algorithm_math/: Algorithm_math.c
  group Driver
    ../BSP/ADC/: adc.c
    ../BSP/LED/: led.c
    ../BSP/SPI/: Spi.c
    ../BSP/IIC/: I2C.c
    ../BSP/KEY/: KEY.c
    ../BSP/OLED/: oled.c
    ../BSP/MOTOR/: moto.c
    ../BSP/TIM/: time.c
    ../BSP/UART/: usart.c
    ../BSP/Delay/: delay.c
    ../BSP/EEPROM/: eeprom.c
    ../BSP/MS5611/: MS5611.c
    ../BSP/MPU6050/: mpu6050.c
    ../BSP/HMC5883/: hmc5883.c
    ../BSP/NRF24L01/: NRF24L01.c
    ../BSP/PWM_IN/: Tim_PWM_IN.c
  group SYS
    ./: main.c stm32f10x_it.c
  group APP
    ../BSP/IMU/: IMU.c
    ../BSP/APP/: app.c
    ../BSP/PARAM/: Param.c
    ../BSP/CONTROL/: CONTROL.c
